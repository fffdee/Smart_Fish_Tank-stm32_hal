# Keil uVision project hal_template.uvprojx, settings and files
target hal_template (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F031C6Tx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00001000) IROM(0x08000000,0x00008000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: hal_template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F031x6,USE_HAL_DRIVER,STM32F031x6
  c include: ../Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/STM32F0xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include;.\Hardware\BEEP;.\Hardware\LED;.\Hardware\KEY;.\Hardware\DS18B20;.\Hardware\UARST;..\Drivers\STM32F0xx_HAL_Driver\Inc;.\FreeRTOS\include;.\Hardware\oled;.\Hardware\TSW-30;.\Hardware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32f031x6.s
  group Application/User
    ../Src/: main.c stm32f0xx_it.c stm32f0xx_hal_msp.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal.c stm32f0xx_hal_gpio.c stm32f0xx_hal_dma.c stm32f0xx_hal_cortex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_usart.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_adc.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Hardware
    ./Hardware/BEEP/: beep.c
    ./Hardware/LED/: led.c
    ./Hardware/KEY/: key.c
    ./Hardware/DS18B20/: ds18b20.c
    ./Hardware/UARST/: uarst1.c
    ./Hardware/oled/: oled.c
    ./Hardware/TSW-30/: tsw_30.c
    ./Hardware/: function.c
  group FreeRTOS
    ./FreeRTOS/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c croutine.c port.c heap_4.c
software components: CMSIS:CORE 5.5.0
